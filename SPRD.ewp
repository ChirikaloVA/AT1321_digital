# IAR project SPRD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2388 NXP LPC2388
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; SUBVER="PULT"; SDL; PULT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPiRiD1.hex
  ILINK.IlinkOutputFile: SPRD.out
  ILINK.IlinkIcfFile: LPC2388.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Debug SNM (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: SPiRiD1_SNM.hex
configuration BNC (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: SPiRiD1_BNC.hex
configuration IAEA SNM (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: SPiRiD1IAEASNM.hex
configuration GPS_BLUETOOTH_FREE (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  OBJCOPY.OOCOutputFile: SPiRiD1_RF.hex
configuration Pult (ARM, debug)
  as the first configuration, except:
configuration PultGM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; SUBVER="PULT"; SDL; PULT; PULT_GM
  group (top)
    ./: cstartup.s main.c main.h types.h
  group Bluetooth
    ./: bluetooth.c bluetooth.h
  group Clock
    ./: clock.c clock.h
  group Display
    ./: display.c display.h display2.c
  group EEPROM
    ./: eeprom.c eeprom.h filesystem.c filesystem.h filesystem2.c ini_control.c ini_control.h
  group Geiger
    ./: geiger.c geiger.h
  group GPS
    ./: gps.c gps.h NMEA_Parser.c NMEA_Parser.h
  group Identify
    ./: identify.c identify.h
  group InterProc
    ./: interProc.c interProc.h interProc2.c
  group Interrupts Sync
    ./: interrupts.c interrupts.h syncObj.c syncObj.h
  group Keyboard
    ./: keyboard.c keyboard.h
  group Math
    ./: puasson.c puasson.h spline.c spline.h
  group MD5
    ./: crc32.c crc32.h
  group misc
    ./: library.lib todo.txt troubles.txt tz.txt Описание программы SPIRID1.txt Описание программы SPIRID1_BNC.txt Описание программы SPIRID1_RF.txt Описание программы SPIRID1_SNM.txt Описание программы SPIRID1IAEASNM.txt Описание программы SPRD.txt
  group Modes
    ./: COMM_mode.c COMM_mode.h edit.c edit.h file_list.c file_list.h GPS_mode.c GPS_mode.h Info_mode.c info_mode.h LOG_mode.c LOG_Mode.h MCS_mode.c MCS_mode.h Message_mode.c Message_mode.h modes.c modes.h rid.c rid.h Setup_mode.c Setup_mode.h spectrum.c Spectrum.h SPRD_mode.c SPRD_mode.h Stab_mode.c STAB_mode.h TC_mode.c TC_mode.h USB_mode.c USB_mode.h YESNO_mode.c yesno_mode.h
  group Power control
    ./: powerControl.c powerControl.h
  group Sound
    ./: sound.c sound.h
  group USBRS
    ./: USBRS.c USBRS.h
